# Keil uVision project lighter.uvproj, settings and files
target Target 1 (MCS-51)
  device: SC92F8362 SC92Fxx Series
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF)  XRAM(0-0x2FF) CLOCK(24000000)
  output: lighter
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: STARTUP.A51
